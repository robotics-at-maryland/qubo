# IAR project usb_dev_gamepad.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RA1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_gamepad.bin
  ILINK.IlinkOutputFile: usb_dev_gamepad.out
  ILINK.IlinkIcfFile: usb_dev_gamepad.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: buttons.c
    ./: startup_ewarm.c usb_dev_gamepad.c usb_gamepad_structs.c
    ../../../../utils/: uartstdio.c
